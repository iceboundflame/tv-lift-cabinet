# Autodesk Inventor part: Wheel
Saved by Autodesk Inventor 2021.3 (Build 253353000, 353)
## iProperties
Created: 2023-01
Part Number: Wheel
Material: Generic
Document SubType Name: Modeling
Designer: AdminForWorker
Density: 1 g/cm^3
Appearance: Default
Title: Wheel
Author: AdminForWorker
## Design history (mm, degrees)
feature "Wheel"
body "Solid1"
